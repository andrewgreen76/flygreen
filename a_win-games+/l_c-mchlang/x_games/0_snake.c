#include <stdio.h>
#include <unistd.h>
#include <termios.h>
#include <fcntl.h>

int ch = 0;
int good_to_exit = 0;

/******************************************************************/
/******************************************************************/
/******************************************************************/

void redisplay_all(){
}

/******************************************************************/
/******************************************************************/
/******************************************************************/

void assess_snakehead(){
}

/******************************************************************/
/******************************************************************/
/******************************************************************/

int kbhit(void) {
  struct termios oldt, newt;
  int oldf;

  tcgetattr(STDIN_FILENO, &oldt);
  newt = oldt;
  newt.c_lflag &= ~(ICANON | ECHO); 
  tcsetattr(STDIN_FILENO, TCSANOW, &newt);
  oldf = fcntl(STDIN_FILENO, F_GETFL, 0);
  fcntl(STDIN_FILENO, F_SETFL, oldf | O_NONBLOCK);

  ch = getchar();

  tcsetattr(STDIN_FILENO, TCSANOW, &oldt);
  fcntl(STDIN_FILENO, F_SETFL, oldf);

  if(ch != EOF) {    // Was pressed.
    ungetc(ch, stdin);
    return 1;
  }
  
  return 0;
}

/******************************************************************/
/******************************************************************/
/******************************************************************/

void read_key(){

  sleep(1);  // Take 1s to register key input.
  
  if (kbhit()) {
    good_to_exit = 1;
  }
  
}

/******************************************************************/
/******************************************************************/
/******************************************************************/

void advance_gamestate(){
}

/******************************************************************/
/******************************************************************/
/******************************************************************/

int main() {

  // Game loop :
  while(!good_to_exit) {
    redisplay_all();
    assess_snakehead();
    read_key();
    advance_gamestate();
  }
  
  return 0;
}
